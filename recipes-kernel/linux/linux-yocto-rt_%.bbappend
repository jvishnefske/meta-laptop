COMPATIBLE_MACHINE_genericx86="(genericx86)"
KMACHINE_genericx86="common-pc"
